# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1
  c include: .;.\FreeRTOS\source\include;.\FreeRTOS\source\portable\RVDS\ARM_CM4F;.\Libraries\
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: startup_rvmdk.S main.c
  group FreeRTOS
    ./FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ./FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ./FreeRTOS/Source/portable/MemMang/: heap_1.c
    ./: FreeRTOSConfig.h
    ./FreeRTOS/Source/include/: timers.h
  group Libraries
    ./Libraries/driverlib/rvmdk/: driverlib.lib
